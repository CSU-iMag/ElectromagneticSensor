# Keil uVision project MagnetSensor.uvprojx, settings and files
target MagnetSensor (6140000::V6.14::ARMCLANG)
  device: MK66FX1M0VLQ18 NXP
  pack: NXP.MK66F18_DFP.12.1.0
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x10000000,0x040000) IROM2(0x00000000,0x100000) XRAM(0x20000000,0x030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT=1, __ARM_FP=0x6, DEBUG, CPU_MK66FX1M0VLQ18, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..\RTE\Board_Support\MK66FX1M0VLQ18;..\RTE\Board_Support\MK66FN2M0VMD18
  asm define: CPU_MK66FN2M0VMD18, DEBUG, KEIL, FRDM_K66F180M, FREEDOM, DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: main.c dft.c
    ../RTE/Board_Support/MK66FX1M0VLQ18/: clock_config.c peripherals.c pin_mux.c board.c
target hello_world release (ARM-ADS)
  device: MK66FN2M0VMD18 NXP
  pack: NXP.MK66F18_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK66FN2M0VMD18, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FRDM_K66F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: ;..;..
  asm define: CPU_MK66FN2M0VMI18, NDEBUG, KEIL,FRDM_K66F, FREEDOM, NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK66FN2M0xxx18_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:CMSIS:MK66F18_header 1.0.0, Device:SDK Drivers:adc 2.0.3, Device:SDK Drivers:clock 2.5.1, Device:SDK Drivers:common 2.2.2, Device:SDK Drivers:dmamux 2.0.4, Device:SDK Drivers:edma 2.3.0, Device:SDK Drivers:gpio 2.4.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:pit 2.0.2, Device:SDK Drivers:port 2.1.0, Device:SDK Drivers:smc 2.0.6, Device:SDK Drivers:uart 2.2.0, Device:SDK Drivers:uart_adapter 1.0.0, Device:SDK Drivers:uart_edma 2.2.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:MK66F18_startup 1.0.0
